<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\3.Project_KSK\4.Project_Build\KSK.ewp</path>
    </project>
    <batchBuild />
</workspace>
