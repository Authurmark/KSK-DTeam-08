# IAR project APhi_Navigator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; ..\..\3.Project_APhi_Navigator\1.Config_kernel; ..\..\3.Project_APhi_Navigator\2.MainSource; ..\..\3.Project_APhi_Navigator\3.ProjectTask\1.Kernel_Task\1.IO_Kernel_Task; ..\..\2.Lib\3.ST_Lib\STM32F10x_StdPeriph_Driver\inc; ..\..\2.Lib\3.ST_Lib\CM3\DeviceSupport\ST\STM32F10x; ..\..\2.Lib\3.ST_Lib\CM3\IAR; ..\..\2.Lib\1.H3ElTeam_Lib; ..\..\2.Lib\1.H3ElTeam_Lib\3.Utilities; ..\..\2.Lib\1.H3ElTeam_Lib\4.UsefulFunction; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\IO_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\Timer_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\USART_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\SPI_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\RTC_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\DMA_ADC_Function; ..\..\2.Lib\1.H3ElTeam_Lib\2.MCU_Functions\Watchdog_Function; ..\..\2.Lib\1.H3ElTeam_Lib\1.Ext_Functions\1.Hardware_Driver\1.nRF24L01+; ..\..\2.Lib\1.H3ElTeam_Lib\1.Ext_Functions\1.Hardware_Driver\3.SI_4432; ..\..\2.Lib\1.H3ElTeam_Lib\1.Ext_Functions\1.Hardware_Driver\4.LCD_OLED; ..\..\2.Lib\1.H3ElTeam_Lib\1.Ext_Functions\1.Hardware_Driver\5.Accelometer; ..\..\2.Lib\1.H3ElTeam_Lib\1.Ext_Functions\2.Network_Layer\1.RF_MeshNet; ..\..\2.Lib\2.OS\1.FreeRTOS; ..\..\2.Lib\2.OS\1.FreeRTOS\1.FreeRTOSV10.0.0.0\Source\portable\IAR\ARM_CM3; ..\..\2.Lib\2.OS\1.FreeRTOS\1.FreeRTOSV10.0.0.0\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\2.Lib\2.OS\1.FreeRTOS
  OBJCOPY.OOCOutputFile: APhi_Navigator.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\3.Project_APhi_Navigator\2.MainSource\\stm32f103x8_FWWithBootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group 1.ProjectConfigFile
    ../1.Config_kernel/: Global_Custom_Define.h Hardware_Function_Profile.c Hardware_Function_Profile.h PointerFunctionDefine.h
    ../2.MainSource/: Project_Function.c
  group 2.MainSource
    ../2.MainSource/: main.c stm32f10x_it.c
  group 2.MainSource/2.1.Kernel_Task/2.1.1.IO_Kernel_Task
    ../3.ProjectTask/1.Kernel_Task/1.IO_Kernel_Task/: IO_Kernel_Function.c IO_Kernel_Task.c
  group 2.MainSource/2.2.Application_Task
    ../3.ProjectTask/2.Application_Task/1.User/: UserTask.c
  group 3.Kernel/3.1.IO_Kernel
    ../../2.Lib/1.H3ElTeam_Lib/2.MCU_Functions/IO_Function/: IO_Function.c
  group 3.Kernel/3.2.Timer_Kernel
    ../../2.Lib/1.H3ElTeam_Lib/2.MCU_Functions/Timer_Function/: Time_Manage_Function.c Timer_Function.c
  group 3.Kernel/3.3.USART_Kernel/3.3.1.USART1_Kernel
    ../../2.Lib/1.H3ElTeam_Lib/2.MCU_Functions/USART_Function/: USART1_AppCall_Function.c USART1_Function.c
  group 3.Kernel/3.3.USART_Kernel/3.3.2.USART2_Kernel
    ../../2.Lib/1.H3ElTeam_Lib/2.MCU_Functions/USART_Function/: USART2_AppCall_Function.c USART2_AppCall_Function.h USART2_Function.c USART2_Function.h USART2_Function_Profile.h
  group 4.Libs/4.1.ST_Lib
    ../../2.Lib/3.ST_Lib/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group 4.Libs/4.1.ST_Lib/4.1.1.Startup_asm
    ../../2.Lib/3.ST_Lib/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd_freertos.s startup_stm32f10x_md_freertos.s
  group 4.Libs/4.1.ST_Lib/4.1.2.CMCIS_Periphrial/4.1.2.1.Standard_Periph
    ../../2.Lib/3.ST_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group 4.Libs/4.2.H3ElTeam_Libs/4.2.1.Utilities
    ../../2.Lib/1.H3ElTeam_Lib/3.Utilities/: Common.h PlatFormType.h Utilities.c
  group 4.Libs/4.2.H3ElTeam_Libs/4.2.2.Useful_Function
    ../../2.Lib/1.H3ElTeam_Lib/4.UsefulFunction/: ringbuf.c
  group 5.OS/5.1.FreeRTOS_v10.0.0.0
    ../../2.Lib/2.OS/1.FreeRTOS/1.FreeRTOSV10.0.0.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../2.Lib/2.OS/1.FreeRTOS/1.FreeRTOSV10.0.0.0/Source/portable/MemMang/: heap_2.c
  group 5.OS/5.1.FreeRTOS_v10.0.0.0/5.1.1.Port_ST_M3
    ../../2.Lib/2.OS/1.FreeRTOS/1.FreeRTOSV10.0.0.0/Source/portable/IAR/ARM_CM3/: port.c portasm.s
