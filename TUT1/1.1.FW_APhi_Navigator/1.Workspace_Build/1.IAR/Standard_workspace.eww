<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\3.Project_APhi_Navigator\4.Project_Build\APhi_Navigator.ewp</path>
    </project>
    <project>
        <path>E:\Le Bien\encoder\enc.ewp</path>
    </project>
    <project>
        <path>E:\Le Bien\du an R&amp;D\pro.ewp</path>
    </project>
    <batchBuild />
</workspace>
